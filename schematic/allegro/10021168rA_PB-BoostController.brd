# Allegro board 10021168rA_PB-BoostController.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EMCABLE_TERMA: length 2.4
  TOP w0.635: J13.1 71.49,7.53 72.33,8.37 R81.2
EMCABLE_TERMB: length 2.9
  TOP w0.635: Q3.3 69.5,7.37 69.48,7.35 J13.2
ENC_A: length 22.8
  TOP w0.203: v1(111.58,41.55) 111.58,43.05 110.29,44.35 107.26,44.35 106.74,44.88 R66.1
  INR1 w0.203: J11.4 117.83,30.12 117.17,30.78 117.17,34.47 111.58,40.06 v1(111.58,41.55)
ENC_B: length 17.9
  TOP w0.203: R69.1 112.57,44.02 115.16,41.43 120.5,41.43 123.19,38.73 123.19,37.47 121.85,36.12 J11.5
ENC_Z: length 21.8
  TOP w0.203: v1(107.65,39.9) 107.03,39.29 R63.1
  INR1 w0.203: J11.3 117.58,33.3 117.58,34.95 114.66,37.87 114.66,40.26 112.63,42.28 108.03,42.28 107.65,41.89 v1(107.65,39.9)
HALL_U: length 33.9
  INR1 w0.203: v1(107.79,47.42) 110.92,44.28 115.07,44.28 116.92,42.44 122.76,42.44 124.66,40.54 124.66,32.16 122.63,30.12 121.69,30.12 121.69,30.12 J11.8
  BOTTOM w0.203: R79.1 v1(107.79,47.42)
HALL_V: length 38.7
  INR1 w0.203: v1(100.91,49.94) 108.15,42.7 115.39,42.7 116.44,41.65 121.9,41.65 123.68,39.88 123.68,32.82 122.98,32.12 J11.7
  BOTTOM w0.203: v1(100.91,49.94) 100.91,49.27 100.81,49.16 R76.1
HALL_W: length 20.9
  INR1 w0.203: v1(118.82,39.52) 119.84,40.54 122,40.54 123.14,39.4 123.14,35.46 121.87,34.19 121.75,34.19 121.69,34.12 J11.6
  BOTTOM w0.203: v1(118.82,39.52) 114,39.52 112.29,37.82 R75.1
LASERRNGPWR_15V_INPUT: length 24.1
  TOP w0.635: U22.8 59.66,10.82 58.67,10.82 ; 58.67,10.82 v1(58.67,10.54) ; 58.67,10.82 v1(58.67,11.28) R73.1
  INR1 w0.635: J10.6 46.56,7.9 46.56,9.93 48.46,11.84 58.12,11.84 v1(58.67,11.28) v1(58.67,10.54)
  BOTTOM w0.635: J10.6 48.04,5.88 46.83,4.66 R88.2
LASERRNGPWR_15V_SWITCHED: length 11.7
  TOP w0.635: Q1.2 58.75,15.48 55.72,12.45 F4.2
MCLR: length 19.6
  TOP w0.203: v1(106.38,11.71) 110.31,11.71 112.34,9.68 v1(113.4,9.68) ; R4.2 99.9,14.63 102.06,12.47 v1(102.06,11.58)
  BOTTOM w0.203: v1(102.06,11.58) 105.71,11.58 105.84,11.71 v1(106.38,11.71) 106.55,11.89 U1.13 ; v1(113.4,9.68) R24.1
OSC1: length 10.2
  BOTTOM w0.203: R5.2 R6.2 ; R6.2 105.25,31.8 105.27,31.78 C6.1 105.27,31.24 105.91,30.6 105.91,30.41 106.55,29.76 U1.63 ; R6.2 105.25,34.93 Y2.1
OSC2: length 8.1
  BOTTOM w0.203: U1.64 107.05,29.91 106.85,30.12 C7.1 106.85,31.39 107.25,31.8 R6.1 107.25,34.07 107.9,34.72 Y2.2
PHASEA: length 26.9
  TOP w0.203: JR1.2 v1(89.87,45.24) 89.87,45.2 89.36,44.69 U3.1
  INR1 w0.203: v1(88.9,33.66) 88.9,44.27 v1(89.87,45.24)
  BOTTOM w0.203: 82.12,30 82.12,30.29 81.91,30.5 U5.2 ; 82.12,30 82.12,29.23 82.37,28.98 85.03,28.98 87.83,31.77 87.83,31.77 88.9,32.84 v1(88.9,33.66) ; 82.12,30 U5.3
PHASEB: length 16.1
  TOP w0.203: v1(73.86,37.87) JR3.2 71.03,37.87 70.77,38.13 U7.1
  BOTTOM w0.203: v1(73.86,37.87) 73.1,37.11 73.1,31.9 75.51,29.49 75.99,29.49 76,29.5 U5.5
PSIGA_10V: length 2
  BOTTOM w0.203: R51.1 7.44,13.74 7.35,13.65 J7.2
PSIGB_10V: length 2.1
  BOTTOM w0.203: J8.2 22.86,7.35 22.92,7.4 R54.1
PWM1H: length 7
  TOP w0.203: J12.1 117.58,20.12 116.79,19.33 v1(116.79,17.42)
  BOTTOM w0.203: U1.94 116.33,17.88 v1(116.79,17.42)
PWM1L: length 4.6
  BOTTOM w0.203: U1.93 117.57,18.38 117.83,18.12 J12.2
PWM2H: length 5.3
  TOP w0.203: v1(116.15,14.88) 117.39,16.12 J12.3
  BOTTOM w0.203: v1(116.15,14.88) 115.66,15.38 U1.99
PWM2L: length 5.3
  BOTTOM w0.203: U1.98 115.26,15.88 115.27,15.88 117.01,15.88 J12.4
PWM3H: length 26.5
  BOTTOM w0.203: U1.3 111.55,11.03 111.76,10.82 115.9,10.82 117.05,9.68 122.12,9.68 123.55,11.1 123.55,19.05 122.48,20.12 J12.5
PWM3L: length 19.7
  BOTTOM w0.203: J12.6 121.69,18.12 123.14,16.67 123.14,11.46 122,10.31 119.08,10.31 115.08,14.3 115.08,14.62 114.82,14.88 U1.100
PWM4L: length 24.2
  TOP w0.203: J12.7 122.41,16.12 123.14,15.39 v1(123.14,9.04)
  BOTTOM w0.203: U1.4 111.05,10.95 111.59,10.41 115.54,10.41 116.92,9.04 v1(123.14,9.04)
RB3_ENC_Z: length 33.9
  TOP w0.203: R64.2 105.24,43.34 104.85,42.95 104.85,27.69 103.23,26.06 v1(102.69,26.06) 102.69,25.53 102.62,25.45 R65.1
  BOTTOM w0.203: U1.22 102.05,25.42 v1(102.69,26.06)
RB4_ENC_A: length 39.6
  TOP w0.203: R68.1 103,27.41 v1(103.33,27.08) 104.22,27.97 104.22,48.67 104.48,48.93 R67.2
  BOTTOM w0.203: v1(103.33,27.08) 103.33,25.55 102.54,24.77 102.54,20.64 102.55,20.63 U1.21
RB5_ENC_B: length 44.9
  TOP w0.203: R71.1 113.32,48.95 113.3,48.93 R70.2 111.71,48.93 111.56,48.77 111.56,44.29 112.43,43.42 112.43,41.38 111.58,40.54 111.58,39.65 110.82,38.89 107.77,38.89 105.3,36.42 105.3,27.53 104.22,26.44 v1(104.22,24.92)
  BOTTOM w0.203: U1.20 103.05,23.75 v1(104.22,24.92)
RB6_PGEC1: length 21.6
  TOP w0.203: J3.5 104.63,4.11 102.29,4.11 101.3,5.11 101.3,8.08 103.58,10.37 103.58,13.49 102.54,14.53 v1(101.44,14.53)
  BOTTOM w0.203: v1(101.44,14.53) 100.2,14.53 99.85,14.88 U1.26
RB7_PGED1: length 23.9
  TOP w0.203: v1(100.53,15.14) 100.53,14.57 102.95,12.16 102.95,10.31 100.89,8.26 100.89,4.24 101.42,3.71 106.22,3.71 J3.4
  BOTTOM w0.203: U1.27 100.33,15.38 100.53,15.18 v1(100.53,15.14)
RD0-CANLB: length 105.2
  INR1 w0.203: v1(110.57,27.2) 110.57,26.11 105.05,20.6 100.28,20.6 99.45,19.77 95.78,19.77 94.41,21.13 76.66,21.13 76.01,21.78 58.02,21.78 54.48,25.32 28.1,25.32 27.44,24.66 v1(23.44,24.66)
  BOTTOM w0.203: U1.72 111.05,27.41 110.85,27.2 v1(110.57,27.2) ; v1(23.44,24.66) 15.57,24.66 14.94,24.03 U8.5
RD1-5VPG: length 58
  TOP w0.203: v1(71.69,24.28) C37.1 71.69,27.11 71.72,27.14 R20.2 71.72,28.09 70.82,28.09 70.43,28.47 70.43,32.38 69.91,32.91 U7.15
  INR1 w0.203: v1(71.69,24.28) 72.59,24.28 72.72,24.41 88.98,24.41 89.99,23.39 92.53,23.39 98.25,29.11 107.65,29.11 109.42,27.33 v1(109.42,26.47)
  BOTTOM w0.203: U1.76 111.13,26.88 110.72,26.47 v1(109.42,26.47)
RD2_GASBYPASS_EN: length 51.1
  INR1 w0.203: v1(107.77,22) 107.77,19.33 109.55,17.55 109.55,13.11 106.53,10.08 88.95,10.08 87.84,11.2 82.75,11.2 81.61,10.06 81.61,9.55 J14.2
  BOTTOM w0.203: v1(107.77,22) 107.77,23.57 109.41,25.2 110.15,25.2 111.32,26.38 U1.77
RD3_STEPPER_ENABLE: length 48.9
  INR1 w0.203: J14.1 82.48,10.17 83.01,10.69 87.77,10.69 88.78,9.68 106.7,9.68 109.96,12.94 109.96,18.27 108.41,19.82 v1(108.41,20.73)
  BOTTOM w0.203: v1(108.41,20.73) 109.04,21.36 109.04,23.52 111.4,25.88 U1.78
RD4_HALL_W: length 48.7
  BOTTOM w0.203: C82.1 102.97,43.36 102.25,42.64 DN6.3 102.25,39.71 103.07,38.89 108.03,38.89 108.34,39.2 R75.2 112.02,39.2 113.36,40.54 121.25,40.54 122.76,39.03 122.76,27.21 119.92,24.38 U1.81
RD5_HALL_V: length 52
  INR1 w0.203: v1(107.62,45.21) 104.34,48.49 v1(104.34,49.81)
  BOTTOM w0.203: U1.82 120,23.88 123.16,27.04 123.16,39.2 121.22,41.15 117.6,41.15 114.53,44.22 108.61,44.22 v1(107.62,45.21) ; v1(104.34,49.81) 103.87,49.34 C84.1 R76.2 102.19,46.67 102.12,46.61 DN7.3
RD6_HALL_U: length 46.5
  BOTTOM w0.203: U1.83 120.71,23.38 124.21,26.88 124.21,39.24 121.41,42.04 117.47,42.04 114.88,44.63 110.41,44.63 109.74,45.3 DN8.3 109.74,47.14 109.17,47.71 R79.2 C85.1
RD12_LRF_EN: length 68.7
  TOP w0.203: v1(63.5,7.32) U22.4 63.5,3.94 63.45,3.9 R74.1
  INR1 w0.203: v1(63.5,7.32) 63.5,8.59 67.13,12.22 72.09,12.22 72.57,12.7 87.86,12.7 89.66,10.9 102.54,10.9 103.45,11.81 103.45,15.77 105.23,17.55 v1(105.99,17.55)
  BOTTOM w0.203: U1.79 111.67,25.38 109.68,23.38 109.68,20.73 107.77,18.82 107.26,18.82 v1(105.99,17.55)
RD13_NFAULT_LRFPOW: length 67.9
  TOP w0.203: U22.3 62.23,7.32 63.83,8.92 v1(65.1,8.92)
  INR1 w0.203: v1(107.39,17.55) 107.39,17.02 107.16,16.79 105.11,16.79 103.86,15.54 103.86,11.64 102.71,10.49 89.49,10.49 87.69,12.29 72.74,12.29 69.36,8.92 v1(65.1,8.92)
  BOTTOM w0.203: U1.80 112.31,24.88 111.46,24.03 111.46,21.62 v1(107.39,17.55) ; R72.2 64.34,9.14 64.57,8.92 v1(65.1,8.92)
RF6_RS232_NINVALID: length 25.8
  BOTTOM w0.203: U9.2 84.76,23.25 85.7,24.19 85.7,26.6 90.75,31.65 100.42,31.65 102.55,29.51 U1.55
RF12: length 102
  TOP w0.203: v1(12.65,45.62) 12.34,45.31 U10.2
  INR1 w0.203: v1(12.65,45.62) 12.27,45.24 12.27,42.61 12.95,41.94 15.5,41.94 21.49,35.94 53.86,35.94 58.87,30.94 82.13,30.94 84.72,28.35 90.37,28.35 v1(92.41,26.31)
  BOTTOM w0.203: U1.40 97.04,21.88 96.49,22.42 96.49,25.02 95.2,26.31 v1(92.41,26.31)
RF13: length 102.7
  TOP w0.203: v1(11.38,45.62) 11.69,45.31 U10.3
  INR1 w0.203: v1(92.28,25.43) 90.12,27.58 84.9,27.58 81.96,30.53 58.55,30.53 53.55,35.53 21.32,35.53 15.33,41.53 12.32,41.53 11.76,42.09 11.76,45.24 v1(11.38,45.62)
  BOTTOM w0.203: v1(92.28,25.43) 94.95,25.43 96.09,24.28 96.09,22.25 96.98,21.36 97.39,21.36 97.41,21.38 U1.39
RG12_EMFLT_A: length 64.7
  INR1 w0.203: v1(112.85,15.39) 112.85,14.12 115.27,11.71 v1(115.27,8.92)
  BOTTOM w0.203: U1.96 113.26,16.88 112.85,16.47 v1(112.85,15.39) ; v1(115.27,8.92) 115.27,7.39 110.79,2.92 82.76,2.92 82.72,2.88 R83.2 81.3,2.18 79.71,2.18 78.97,2.92 76.94,2.92 75.64,4.22 75.64,7.01 74.5,8.15 71.07,8.15 70.34,8.89 70.34,9.53 69.9,9.97 U24.1
RG13_EMFLT_B: length 65.4
  INR1 w0.203: v1(115.9,16.92) 113.03,16.92 112.14,16.03 112.14,13.82 114.38,11.58 v1(114.38,8.92)
  BOTTOM w0.203: U1.97 115.36,16.38 v1(115.9,16.92) ; U24.6 72.27,9.97 72.7,9.54 72.7,9.02 73.16,8.56 74.67,8.56 76.05,7.18 76.05,4.39 77.11,3.33 80.52,3.33 R85.2 81.16,3.96 83.13,3.96 83.77,3.33 110.62,3.33 114.76,7.46 114.76,8.53 v1(114.38,8.92)
RG14_EMFLT_C: length 47.8
  TOP w0.203: U23.3 v1(74.12,20.73)
  INR1 w0.203: v1(74.12,20.73) 74.65,20.73 74.78,20.6 89.36,20.6 90.75,19.2 96.85,19.2 97.36,18.69 102.95,18.69 103.35,18.29 107.8,18.29 108.53,17.55 v1(108.53,15.65)
  BOTTOM w0.203: v1(74.12,20.73) 74.67,21.28 R77.2 ; U1.95 112.93,17.38 111.2,15.65 v1(108.53,15.65)
RG15_EMFLT_EN: length 47.2
  TOP w0.203: v1(78.94,22.66) 78.41,22.66 78.38,22.63 77.93,22.63 77.29,22 U23.4
  INR1 w0.203: v1(78.94,22.66) 95.99,22.66 96.85,23.52 103.07,23.52 v1(103.71,22.89)
  BOTTOM w0.203: R80.1 v1(78.94,22.66) ; v1(103.71,22.89) 103.71,16.66 104.47,15.9 106.88,15.9 108.03,14.76 111.96,14.76 112.55,14.17 U1.1
RS232_CTS: length 18.9
  BOTTOM w0.203: U9.20 83.49,9.58 86.94,6.12 86.94,4.85 87.58,4.22 93.17,4.22 J5.4
RS232_RTS: length 13.9
  BOTTOM w0.203: U9.19 84.76,9.32 85.17,8.92 88.72,8.92 89.87,10.06 92.66,10.06 93.37,9.35 J5.2
RS232_RXD: length 14
  TOP w0.203: v1(92.41,20.09) 92.41,9.45 J5.3
  BOTTOM w0.203: U9.8 92.38,20.74 92.41,20.72 v1(92.41,20.09)
RS232_TXD: length 17.6
  TOP w0.203: J5.1 93.29,10.49 93.29,20.5 92.94,20.85 91.72,20.85 91.52,20.65 v1(91.52,20.09)
  BOTTOM w0.203: v1(91.52,20.09) 91.11,20.5 U9.7
RS485_A: length 5
  TOP w0.203: J4.2 9.18,37.39 10.83,37.39 11.69,38.25 U10.6
RS485_B: length 5.8
  TOP w0.203: U10.7 12.34,38.32 11,36.98 9.25,36.98 J4.1
SOSCI: length 5.2
  BOTTOM w0.203: U1.73 111.55,29.63 111.44,29.74 C5.1 111.44,31.79 111.3,31.94 111.1,31.94 110.36,32.67 Y1.2
SOSCO: length 5
  BOTTOM w0.203: Y1.1 112.91,33.03 112.91,31.06 C4.1 112.61,30.76 112.61,30.12 112.05,29.57 U1.74
U1CTS: length 20.5
  INR1 w0.203: v1(90.88,25.17) v1(84.53,25.17)
  BOTTOM w0.203: U9.1 83.49,24.13 v1(84.53,25.17) ; v1(90.88,25.17) 90.88,26.57 91.64,27.33 92.66,27.33 93.04,26.95 95.45,26.95 97.02,25.38 U1.47
U1RTS: length 22.6
  BOTTOM w0.203: U1.48 97.1,25.88 94.38,28.6 91.9,28.6 90.12,26.82 90.12,24.12 90.44,23.8 90.44,21.02 89.9,20.47 86.3,20.47 86.03,20.74 U9.3
U1RXD: length 22.4
  BOTTOM w0.203: U9.6 89.84,23.67 88.47,25.04 88.47,28.09 90.75,30.38 95.45,30.38 98.37,27.46 100.85,27.46 101.05,27.66 U1.52
U1TXD: length 22.1
  BOTTOM w0.203: U9.4 87.3,27.56 90.98,31.24 99.03,31.24 100.55,29.72 U1.51
U2RXD: length 96.3
  TOP w0.203: v1(13.16,44.98) 12.99,44.82 U10.1
  INR1 w0.203: v1(91.52,29.24) 84.4,29.24 82.3,31.34 59.18,31.34 54.18,36.35 21.66,36.35 15.57,42.44 13.36,42.44 13.16,42.65 v1(13.16,44.98)
  BOTTOM w0.203: v1(91.52,29.24) 94.44,29.24 97.29,26.38 U1.49
U2TXD: length 102.3
  TOP w0.203: v1(10.87,44.98) 11.04,44.82 U10.4
  INR1 w0.203: v1(10.87,44.98) 10.87,42.09 12.04,40.92 15.36,40.92 21.15,35.13 53.24,35.13 58.24,30.12 81.79,30.12 85.34,26.57 v1(89.23,26.57)
  BOTTOM w0.203: U1.50 97.81,26.88 94.82,29.87 91.01,29.87 89.23,28.09 v1(89.23,26.57)
VOFF: length 42.7
  TOP w0.203: U15.1 49.78,37.26 49.99,37.47 v1(50.62,37.47) ; U13.1 38.08,35.87 38.81,36.6 v1(38.81,37.49) ; U17.1 21.7,35.87 22.05,36.22 v1(22.05,37.49)
  INR1 w0.381: 23.97,37.98 24.21,37.74 35.26,37.74 36.44,38.93 38.81,38.93 ; 23.97,37.98 v1(23.97,39.51) ; 23.97,37.98 22.54,37.98 v1(22.05,37.49) ; v1(38.81,37.49) 38.81,38.93 ; 38.81,38.93 41.18,38.93 42.65,37.47 v1(50.62,37.47)
  BOTTOM w0.203: U19.1 v1(23.97,39.51)
N08765: length 6.3
  TOP w0.203: R1.2 R2.2 109.69,22.09 109.83,22.22 C1.1 109.83,24.3 109.94,24.42 C2.1
N08773: length 3.6
  TOP w0.203: R2.1 112.4,20.98 112.73,21.31 v1(112.73,22.12)
  BOTTOM w0.203: v1(112.73,22.12) 112.98,22.38 U1.85
N14987: length 41.2
  TOP w0.203: R3.2 R4.1 ; R3.2 97.94,12.51 97.99,12.45 97.99,12.22 98.76,11.46 98.76,7.65 99.87,6.53 99.87,3.73 101.04,2.57 JP1.1 ; R3.2 97.35,13.23 97.32,13.21 SW1.4 95.42,14.26 93.85,15.82 93.85,19.51 95.42,21.07 SW1.3
N25385: length 5.8
  TOP w1.016: J11.1 117.83,36.12 115.8,38.15 F5.1
N30214: length 5.3
  TOP w0.635: 107.44,41.02 107.26,41.02 106.91,40.67 R63.2 R64.1 ; 107.44,41.02 DN3.3 ; 107.44,41.02 107.44,41.89 107.78,42.24 C88.1
N30237: length 5.8
  TOP w0.305: R67.1 106.85,47.54 107.06,47.75 107.06,48.27 107.78,49 C87.1
  TOP w0.635: DN4.3 106.32,46.61 R66.2 R67.1
N30262: length 5.9
  TOP w0.635: C89.1 114.79,44.6 114.79,46 DN5.3 112.92,46.61 R69.2 R70.1
N38405: length 21.8
  TOP w0.203: v1(100.28,7.9) 100.28,4.09 101.3,3.07 111.58,3.07 113.61,5.11 JP1.2
  BOTTOM w0.203: v1(100.28,7.9) C3.1
N39747: length 4.4
  TOP w0.203: v1(101.17,17.93) 101.23,18 U2.5
  BOTTOM w0.203: v1(101.17,17.93) 101.17,17.4 100.15,16.38 U1.29
N47726: length 2.5
  BOTTOM w0.203: R24.2 109.9,8.38 109.86,8.42 J3.1
N61961: length 12.4
  TOP w0.203: U13.2 35.56,34.29 35.93,33.92 v1(35.93,33.16) ; R30.2 v1(37.4,38.14)
  BOTTOM w0.203: v1(37.4,38.14) 37.4,38.67 37.08,38.99 C48.2 C50.1 35.8,35.74 35.93,35.61 R31.1 v1(35.93,33.16)
N61969: length 11.1
  TOP w0.203: R36.2 33.91,37.41 34.29,37.03 U13.3 34.29,34.66 33.92,34.29 v1(33.92,33.16)
  BOTTOM w0.203: v1(33.92,33.16) R31.2 33.92,35.61 34.05,35.74 C50.2 32.98,36.7 32.84,36.85 C53.1
N62625: length 10.4
  TOP w0.203: v1(48.88,33.16) 48.88,33.92 48.51,34.29 U15.2
  BOTTOM w0.203: v1(48.88,33.16) R38.1 48.88,35.61 48.75,35.74 C59.1 48.75,37.67 48.86,37.77 C57.2 48.86,39.73 48.84,39.75 R37.2
N62633: length 10.4
  TOP w0.203: v1(46.88,33.16) 46.88,34.29 47.24,34.66 U15.3
  BOTTOM w0.203: R43.2 46.81,38.87 C62.1 46.92,37.75 47.01,37.67 C59.2 47.01,35.74 46.88,35.61 R38.2 v1(46.88,33.16)
N63303: length 11.2
  TOP w0.203: R44.2 19.51,37.02 19.05,36.57 U17.2 19.05,34.29 19.42,33.92 v1(19.42,33.16)
  BOTTOM w0.203: v1(19.42,33.16) R45.1 19.42,35.61 19.29,35.74 C68.1 C66.2
N63311: length 11.1
  TOP w0.203: R50.2 17.4,36.95 17.78,36.57 U17.3 17.78,34.66 17.41,34.29 v1(17.41,33.16)
  BOTTOM w0.203: v1(17.41,33.16) R45.2 17.41,35.61 17.54,35.74 C68.2 16.47,36.7 16.33,36.85 C71.1
N72482: length 16.3
  BOTTOM w0.203: U20.5 16.46,8.66 19.44,11.65 C77.1 22.86,10.94 22.92,10.89 R55.2 24.94,10.03 25.48,10.57 DN9.3
N72600: length 2.9
  BOTTOM w0.203: R52.1 R53.2 R51.2
N72690: length 7.1
  BOTTOM w0.203: U20.3 12.59,14.53 12.58,14.54 R52.2 ; R52.2 13.17,15.27 13.29,15.14 DN10.3 ; R52.2 12.58,15.99 12.61,16.02 C76.1
N72804: length 2.8
  BOTTOM w0.203: R56.2 R54.2 R55.1
N72852: length 5.2
  TOP w1.016: J8.1 24.86,8.27 25.91,9.32 F2.1
N75830: length 5.1
  TOP w1.016: F1.1 7.33,10.74 J7.1
N76571: length 4.9
  TOP w1.016: J9.1 39.37,10.47 F3.1
N76619: length 6.6
  BOTTOM w0.203: R58.1 34.01,11.56 35.32,10.25 J9.2 34.39,8.42 34.3,8.51 R57.2
N76675: length 7.9
  BOTTOM w0.203: R59.1 40.41,11.58 40.38,11.56 R58.2 39.04,8.13 J9.3
N76787: length 45.7
  BOTTOM w0.203: U21.3 60.08,9.48 59.89,9.3 59.89,7.14 59.51,6.76 57.61,6.76 56.34,5.49 56.34,3.45 55.32,2.44 51.4,2.44 50.46,1.5 47.96,1.5 47.02,2.44 44.84,2.44 43.44,3.84 31.57,3.84 30.59,4.81 C78.1 31.83,7.52 31.97,7.67 31.97,8.48 R57.1 31.95,10.44 31.8,10.59 30.95,10.59 DN1.3
N77226: length 8.5
  TOP w0.635: J10.1 52.04,9.53 51.64,9.93 47.65,9.93 46.99,10.59 F4.1
N77274: length 9.9
  BOTTOM w0.203: J10.2 50.04,10.74 50.85,11.56 R62.1 53.7,11.56 54,11.26 54,9.11 53.87,8.99 R60.2
N77330: length 5.8
  BOTTOM w0.203: R61.1 46.14,12.23 R62.2 46.81,9.64 J10.3
N77442: length 24.9
  BOTTOM w0.203: U21.5 55.62,8.83 55.25,8.46 R60.1 55.25,7.34 55.8,6.78 55.8,3.68 55.07,2.95 51.33,2.95 50.29,1.91 48.13,1.91 47.12,2.92 47.12,2.95 45.29,2.95 43.35,4.89 C79.1 43.35,6.44 43.55,6.64 DN2.3
N78880: length 6.9
  TOP w0.203: C45.2 R28.1 29.16,25 ; U12.1 29.17,25.01 29.16,25 ; 29.16,25 28.69,25 28.52,25.18 U12.2
N79170: length 3.9
  TOP w0.203: U11.3 29.09,35.75 28.73,36.11 ; RN1.7 27.83,36.33 28.06,36.11 28.73,36.11 ; 28.73,36.11 RN1.8
N79174: length 3.7
  TOP w0.203: 26.79,36.09 27.03,36.33 RN1.6 ; 26.79,36.09 26.78,36.09 26.37,36.09 26.13,36.33 RN1.5 ; 26.79,36.09 U11.4
N79202: length 15.9
  TOP w0.203: RN1.3 v1(27.03,39.62) ; R26.1 v1(27.19,32.09) 28.19,33.09 U11.1
  BOTTOM w0.203: v1(27.03,39.62) 27.03,39.08 27,39.05 27,38.51 24.46,35.97 24.46,32.44 24.8,32.09 v1(27.19,32.09)
N79426: length 4.4
  TOP w0.203: R26.2 R27.1 30.39,28.57 30.53,28.43 C45.1
N79442: length 4.7
  TOP w0.203: C43.1 26.5,28.56 26.52,28.57 R27.2 27.19,28.41 27.87,27.73 U12.3
N79600: length 8.9
  TOP w0.203: C46.1 27.42,24.88 29.3,23 R28.2 R29.1
N79616: length 7.8
  TOP w0.203: U12.5 27.22,20 28.02,19.2 29.64,19.2 29.65,19.19 v1(30.19,19.19) R29.2
  BOTTOM w0.203: v1(30.19,19.19) 30.5,19.19 30.7,19.39 C44.1
N83438: length 6.8
  TOP w0.203: 39.2,22.21 R34.1 C54.2 ; 39.2,22.21 U14.1 ; 39.2,22.21 38.79,22.21 38.55,22.45 U14.2
N83538: length 4.4
  TOP w0.203: R32.2 R33.1 39.9,25.78 40.04,25.64 C54.1
N83554: length 4.7
  TOP w0.203: U14.3 37.9,24.84 37.23,25.51 R33.2 36.2,25.78 36.18,25.77 C51.1
N83666: length 8.9
  TOP w0.203: R35.1 R34.2 39.35,20.21 37.48,22.08 C55.1
N83682: length 7.9
  TOP w0.203: U14.5 37.25,17.1 37.96,16.4 v1(40.26,16.4) R35.2
  BOTTOM w0.203: C52.1 40.46,16.6 v1(40.26,16.4)
N84265: length 6.8
  TOP w0.203: U16.1 49.11,22.21 ; 49.11,22.21 R41.1 C63.2 ; 49.11,22.21 48.7,22.21 48.46,22.45 U16.2
N84365: length 4.4
  TOP w0.203: C63.1 49.94,25.64 49.8,25.78 R40.1 R39.2
N84381: length 4.7
  TOP w0.203: C60.1 46.09,25.77 46.1,25.78 R40.2 47.13,25.51 47.81,24.84 U16.3
N84493: length 8.9
  TOP w0.203: C64.1 47.39,22.08 49.26,20.21 R41.2 R42.1
N84509: length 7.9
  TOP w0.203: R42.2 v1(50.16,16.4) 47.86,16.4 47.16,17.1 U16.5
  BOTTOM w0.203: C61.1 50.37,16.6 v1(50.16,16.4)
N85113: length 6.8
  TOP w0.203: 19.64,22.21 R48.1 C72.2 ; 19.64,22.21 U18.1 ; 19.64,22.21 19.23,22.21 18.99,22.45 U18.2
N85213: length 4.4
  TOP w0.203: C72.1 20.48,25.64 20.34,25.78 R47.1 R46.2
N85229: length 4.7
  TOP w0.203: U18.3 18.34,24.84 17.67,25.51 R47.2 16.64,25.78 16.62,25.77 C69.1
N85341: length 8.9
  TOP w0.203: C73.1 17.92,22.08 19.8,20.21 R48.2 R49.1
N85357: length 7.3
  TOP w0.203: U18.5 17.69,18.09 19.39,16.4 v1(20.7,16.4) R49.2
  BOTTOM w0.203: C70.1 20.9,16.6 v1(20.7,16.4)
N98820: length 2.8
  TOP w0.203: U22.5 63.5,12.82 63.56,12.88 Q1.1
N98894: length 10.7
  TOP w0.635: R73.2 58.31,8.48 58.99,9.17 61.8,9.17 62.23,9.6 U22.6 62.23,13.23 61.46,14 Q1.3
N99153: length 5.1
  TOP w0.203: U22.2 60.96,4.65 60.23,3.93 C83.1 R74.2
N109964: length 59
  TOP w0.203: v1(100.55,42.45) C17.1 99.39,43.26 99.06,43.59 96.34,43.59 95.58,42.82 U3.13
  BOTTOM w0.203: 79.71,30 79.71,28.83 79.83,28.71 C28.1 ; 79.71,30 79.7,30 U5.6 ; 79.71,30 79.71,30.51 ; 79.71,30.51 79.7,30.5 U5.7 ; 79.71,30.51 79.71,31.01 79.69,31 U5.8
  BOTTOM w0.508: U6.6 78.42,35.68 78.83,36.09 90.91,36.09 ; C27.1 C28.1 80.56,28 80.56,28 81.86,28 81.87,27.99 82.38,27.99 82.39,28 JR2.1 85.33,28 90.91,33.59 90.91,36.09 ; 90.91,36.09 97.27,42.45 v1(100.55,42.45)
N110102: length 5.6
  TOP w0.203: U3.16 R9.1 94.55,45.76 94.82,45.49 R8.1 95.47,46.45 95.6,46.57 C16.1
N110130: length 55.3
  TOP w0.203: v1(95.33,43.59) 95.33,43.52 95.12,43.32 U3.14 ; C16.2 97.34,46.69 97.47,46.56 R8.2 ; C16.2 98.42,47.65 98.44,47.64 R12.1 ; C16.2 v1(97.34,48.82) ; U4.8 83.02,16.75 82.88,16.89 ; U4.7 83.52,16.75 83.39,16.89
  TOP w1.143: C21.1 83.03,18.72 83,18.76 C22.1 83,20.92 82.75,21.16 C23.1
  TOP w1.27: L1.2 94.59,26.35 v1(93.11,27.84) 84.53,27.84 82.75,26.06 C23.1
  INR1 w0.203: v1(97.34,48.82) 97.34,43.7 96.33,42.68 95.33,42.68 ; v1(93.11,27.84) 93.11,32.22 95.33,34.44 95.33,42.68 ; 95.33,42.68 v1(95.33,43.59)
N110228: length 3.8
  TOP w0.203: U4.3 84.02,12.26 84.6,11.67 R10.1 R7.2
N110370: length 13.3
  TOP w0.305: 94.8,40.82 U3.9 93.68,40.28 ; U3.10 94.8,41.32 ; U3.11 94.8,41.82 ; 92.95,37.45 L1.1 ; L1.1 94.95,35.81 ; L1.1 94.95,39.1 ; L1.1 96.94,37.45 ; 96.11,40.66 C18.2 97.23,39.68
N110394: length 3.6
  TOP w0.203: U3.12 94.63,42.32 94.72,42.41 95.75,42.41 95.79,42.45 C18.1
N110516: length 3.5
  TOP w0.203: U3.3 86.86,43.32 86.62,43.08 R11.1
N110530: length 4.1
  TOP w0.203: C19.1 86.82,45.11 88.11,43.82 U3.2
N110898: length 2.7
  TOP w0.203: C26.1 84.96,13.12 84.88,13.05 U4.4
N110954: length 50.5
  TOP w0.203: U3.15 94.67,43.82 95.07,44.22 98.86,44.22 v1(99.39,44.75) R12.2 100.7,45.63 100.72,45.61 C25.1 ; U4.5 85.48,15.96 v1(86.06,16.54)
  BOTTOM w0.203: v1(86.06,16.54) 84.79,16.54 84.15,17.17 84.15,23.27 85.29,24.41 85.29,27.08 92.02,33.81 94.31,33.81 101.3,40.79 101.3,43.71 100.25,44.75 v1(99.39,44.75)
N111056: length 10.6
  TOP w0.203: v1(87.2,42.7) 87.73,42.7 87.85,42.82 U3.4 ; v1(88.07,47.89) R13.2 R15.1
  BOTTOM w0.203: v1(87.2,42.7) 88.07,43.57 v1(88.07,47.89)
N111200: length 5.3
  BOTTOM w0.203: U5.1 80.35,31 79.8,31.55 79.8,34.28 79.94,34.43 U6.1
N111222: length 2
  BOTTOM w0.203: U6.4 77.57,32.53 77.56,32.54 R16.1
N111230: length 1.9
  BOTTOM w0.203: 79.07,33.43 79.34,33.15 79.34,32.05 79.07,31.78
N111288: length 4.6
  BOTTOM w0.203: JR2.2 83.3,29.87 82.12,31.06 82.12,32.37 81.96,32.53 U6.3
N113208: length 13.1
  TOP w0.203: U7.4 68.91,39.64 v1(69.29,40.03) ; R21.2 R23.1 v1(76.39,37.73)
  BOTTOM w0.203: v1(69.29,40.03) 70.43,38.89 75.23,38.89 v1(76.39,37.73)
N113286: length 2.4
  TOP w0.203: D2.C 109.15,33.73 108.35,34.53 R22.1
N113430: length 5.4
  TOP w0.203: R17.1 71.23,33.12 71.07,32.96 70.67,32.96 70.41,33.22 U7.16 ; R17.1 R18.1 ; R17.1 71.7,32.86 C29.1
N113814: length 13.3
  TOP w0.305: 65.77,30.25 C31.2 66.74,31.37 ; 67.41,32.68 U7.10 ; 67.91,32.68 U7.11 ; 66.37,33.81 U7.9 66.91,32.68 ; 64.05,30.92 L2.1 ; L2.1 64.05,34.91 ; L2.1 62.4,32.92 ; L2.1 65.69,32.92
N113838: length 3.6
  TOP w0.203: C31.1 68.54,31.77 68.41,31.9 U7.12
N113850: length 6.9
  TOP w0.203: C30.1 68.79,28.35 69.42,28.35 69.67,28.6 69.67,31.27 68.91,32.03 U7.13
N113978: length 3.8
  TOP w0.203: R19.1 69.67,40.87 70.01,40.53 70.01,39.89 69.41,39.28 U7.3
N113992: length 4.4
  TOP w0.203: U7.2 69.91,39.12 70.82,40.03 70.82,40.93 71.55,41.67 C32.1
N133871: length 2.4
  TOP w0.203: R14.1 79.9,17.04 79.09,16.23 D1.C
N137397: length 13.2
  TOP w0.203: JR4.2 11.18,29.18 12.9,27.46 12.9,22.89 v1(11.13,21.11)
  BOTTOM w0.203: v1(11.13,21.11) U8.8
N140550: length 18.1
  TOP w0.635: Q3.1 67.4,12.09 67.56,12.24 F6.2 67.56,16.54 ; Q2.2 65.69,18.48 67.56,16.61 67.56,16.54 ; 67.56,16.54 67.62,16.6 v1(68.72,16.6)
  BOTTOM w0.635: v1(68.72,16.6) 70.15,18.03 R82.1
N140644: length 4
  BOTTOM w0.203: U24.4 71.93,12.76 71.58,13.11 71.58,13.35 71.56,13.37 R86.2 R87.1
N140824: length 4
  BOTTOM w0.203: U24.3 69.55,13.34 70.18,13.96 R86.1 R84.2
N140988: length 8.2
  TOP w0.203: U23.5 64.47,22 63.58,21.11 63.58,20.4 Q2.1
N141012: length 5.5
  TOP w0.635: U23.6 69.42,20.73 69.22,20.53 R78.2 67.14,20.53 66.04,19.43 Q2.3
N141056: length 6.9
  TOP w0.203: U23.2 v1(74.12,19.46)
  BOTTOM w0.203: R80.2 C86.1 76.9,19.7 76.66,19.46 v1(74.12,19.46)
N141914: length 8.1
  TOP w0.203: Q3.2 66.53,8.32 66.11,8.74 v1(66.11,10.19)
  BOTTOM w0.203: R84.1 67.25,13.37 67.26,13.37 67.26,12.85 67.4,12.71 67.4,10.39 67.2,10.19 v1(66.11,10.19)
N143860: length 5.9
  TOP w0.635: F6.1 73.66,12.24 74.12,11.79 74.12,9.85 73.72,9.45 R81.1
N249678: length 4.2
  BOTTOM w0.203: R89.1 51.02,5.44 ; 51.02,5.44 51.06,5.44 J10.4 ; 51.02,5.44 J10.5

## Copper pours and planes (outline as drawn)
3.3V on TOP: 75.26,7.65 75.26,13.49 83.77,13.49 83.77,11.84 82.37,11.84 82.37,7.65
3.3V on PWR: 0.58,50.32 126.44,50.32 126.44,0.64 0.58,0.64 ; 7 cut-outs
5V on TOP: 45.09,47.62 45.09,39.37 52.7,39.37 52.7,47.62
5V on PWR: 46.43,46.13 55.7,46.13 64.34,37.49 71.32,37.49 74.37,34.44 88.6,34.44 92.41,38.25 92.41,50.32 126.31,50.32 126.44,50.19 126.44,24.41 126.31,24.28 111.46,24.28 106.38,19.2 101.8,19.2 101.8,21.11 107.77,27.08 107.77,32.92 106.12,34.57 100.28,34.57 92.79,27.08 59,27.08 46.43,39.65 ; 2 cut-outs
15V on TOP: 67.39,41.17 67.39,39.78 67.77,39.4 67.77,39.14 68.53,39.14 68.53,40.16 68.28,40.41 68.28,41.17
15V on TOP: 86.26,40.67 87.96,40.67 88.4,41.11 88.47,41.11 88.47,42.32 87.33,42.32 86.62,41.62 86.26,41.62
15V on PWR: 87.96,33.81 74.5,33.81 71.07,37.24 62.18,37.24 53.16,46.25 19.2,46.25 8.46,35.51 8.46,30.4 14.94,23.93 14.94,16.97 9.14,11.18 9.14,6.07 9.6,5.61 10.82,5.61 13.84,8.64 13.84,10.41 17.42,14 25.86,14 27.3,12.63 27.3,11.89 28.11,10.92 30.37,10.92 30.81,11.33 30.81,12.24 29.54,13.51 29.54,15.01 30.56,16.03 36.27,16.03 38.68,13.61 38.68,9.3 39.7,8.28 41.48,8.28 42.49,9.3 42.49,15.01 43.51,16.03 51.77,16.03 56.85,10.95 64.08,10.95 66.75,13.61 66.75,19.25 67.31,19.81 69.09,19.81 74.5,14.4 74.5,0.66 0.58,0.66 0.58,50.32 92.41,50.32 92.41,38.25 ; 1 cut-out
GND_SIGNAL on TOP: 55.7,49.94 103.84,49.94 103.84,36.86 95.83,28.85 82.63,28.85 76.53,22.76 60.78,22.76 55.7,27.84 ; 6 cut-outs
GND_SIGNAL on GND1: 0.64,50.16 126.36,50.16 126.36,0.64 0.64,0.64 ; 9 cut-outs
GND_SIGNAL on GND2: 0.64,50.16 126.36,50.16 126.36,0.64 0.64,0.64 ; 3 cut-outs
Net_8 on TOP (solid shape): 125.43,0.39 119.08,0.39 119.08,7.53 125.43,7.53
Net_9 on TOP (solid shape): 125.43,43.27 119.08,43.27 119.08,50.41 125.43,50.41
Net_10 on TOP (solid shape): 7.92,43.27 1.57,43.27 1.57,50.41 7.92,50.41
Net_11 on TOP (solid shape): 7.92,0.39 1.57,0.39 1.57,7.53 7.92,7.53
N110130 on TOP (solid shape): 83.64,16.66 82.5,16.66 82.5,18.06 83.64,18.06
N110370 on TOP: 92.79,42.06 92.79,35.46 98.37,35.46 98.37,42.06
N111230 on BOTTOM: 79.58,33.93 79.58,31.14 75.01,31.14 75.01,33.93
N113814 on TOP: 62.18,35.08 62.18,29.49 68.28,29.49 68.28,35.08

## Text on the board
User.Comments: CR_P3_5 | CR_P1_3 | CR_P1_4 | CR_PS_1
Ref Des/Silkscreen Top: CAN | RS485 | DIFFP | ENCDR | PWM | PSIGB | VI/MN | LOAD | LRF | PWR | EMC | DIGIO | RS232 | ICD | 10021168rA | PB BOOST | CONTROLLER
XSECTION_CHART: L1: TOP CONDUCTOR - COPPER 1.4 MIL | *  DIELECTRIC - FR-4 5.1 MIL | *  DIELECTRIC - FR-4 4.7 MIL | L2: GND1 CONDUCTOR - COPPER 1.4 MIL | *  DIELECTRIC - FR-4 14 MIL | L3: PWR CONDUCTOR - COPPER 1.4 MIL | *  DIELECTRIC - FR-4 4.2 MIL | L4: INR1 CONDUCTOR - COPPER 1.4 MIL | L5: GND2 CONDUCTOR - COPPER 1.4 MIL | L6: BOTTOM CONDUCTOR - COPPER 1.4 MIL | DESIGN CROSS SECTION CHART | ___________________________ | TOTAL THICKNESS 64.4 MIL | 1-6
DEVICE_TYPE_BOTTOM: FIGURE | SIZE | 10.0 | 32.0 | 38.0 | 40.0 | 44.0 | 126.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | PLATED | QTY | 366 | 72 | 56 | 4 | 2
